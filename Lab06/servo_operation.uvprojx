# Keil uVision project servo_operation.uvprojx, settings and files
target servo_operation (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: servo_operation
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=2
  c define: TARGET_KSDK2_MCUS DEVICE_RTC=1 DEVICE_SLEEP=1 ARM_MATH_CM4 TARGET_KPSDK_CODE TARGET_NAME=K64F __ASSERT_MSG TARGET_RELEASE DEVICE_CRC=1 TARGET_MCU_K64F MBED_BUILD_TIMESTAMP=1557879507.72 TARGET_FRDM DEVICE_PORTINOUT=1 COMPONENT_SD=1 DEVICE_PWMOUT=1 TARGET_FF_ARDUINO TARGET_RTOS_M4_M7 TARGET_Freescale_EMAC DEVICE_SPISLAVE=1 DEVICE_PORTOUT=1 DEVICE_FLASH=1 DEVICE_STDIO_MESSAGES=1 DEVICE_ANALOGOUT=1 TARGET_LIKE_MBED DEVICE_SERIAL_FC=1 DEVICE_LPTICKER=1 FEATURE_STORAGE=1 TARGET_LIKE_CORTEX_M4 TARGET_CORTEX_M DEVICE_SERIAL=1 TARGET_KPSDK_MCUS TARGET_Freescale DEVICE_USTICKER=1 DEVICE_I2C=1 __CORTEX_M4 TARGET_CORTEX TARGET_MCUXpresso_MCUS TOOLCHAIN_ARM DEVICE_INTERRUPTIN=1 DEVICE_ANALOGIN=1 TOOLCHAIN_ARM_STD __CMSIS_RTOS DEVICE_EMAC=1 DEVICE_SERIAL_ASYNCH=1 DEVICE_TRNG=1 DEVICE_SPI=1 __MBED__=1 TARGET_K64F CPU_MK64FN1M0VMD12 DEVICE_STORAGE=1 DEVICE_PORTIN=1 TARGET_M4 __FPU_PRESENT=1 DEVICE_I2CSLAVE=1 FSL_RTOS_MBED DEVICE_SPI_ASYNCH=1 __MBED_CMSIS_RTOS_CM
  c misc: --no_rtti --split_sections -c --cpu=Cortex-M4.fp --no_depend_system_headers --md --gnu --apcs=interwork --preinclude=mbed_config.h
  c include: ;/Servo;/usr/src/mbed-sdk;mbed;mbed/TARGET_K64F/TOOLCHAIN_ARM_STD;mbed/drivers;mbed/hal;mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DFSL_RTOS_MBED
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: .\mbed\TARGET_K64F\TOOLCHAIN_ARM_STD\MK64FN1M0xxx12.sct
  link misc: --show_full_path --keep=os_cb_sections
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawSerial.h Serial.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h TableCRC.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h Driver_Common.h Driver_Storage.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.h lp_ticker_api.h mbed_lp_ticker_wrapper.h pinmap.h port_api.h pwmout_api.h qspi_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o arm_math.h cmsis.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_nvic.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h crc.h crc.o device.h dma_api.o dma_api_hal.h dma_reqs.h flash_api.o fsl_adc16.h fsl_adc16.o fsl_clock.h fsl_clock.o fsl_clock_config.h fsl_clock_config.o fsl_cmp.h fsl_cmp.o fsl_cmt.h fsl_cmt.o fsl_common.h fsl_common.o fsl_crc.h fsl_crc.o fsl_dac.h fsl_dac.o fsl_device_registers.h fsl_dmamux.h fsl_dmamux.o fsl_dspi.h fsl_dspi.o fsl_dspi_edma.h fsl_dspi_edma.o fsl_edma.h fsl_edma.o fsl_enet.h fsl_enet.o fsl_ewm.h fsl_ewm.o fsl_flash.h fsl_flash.o fsl_flexbus.h fsl_flexbus.o fsl_flexcan.h fsl_flexcan.o fsl_ftm.h fsl_ftm.o fsl_gpio.h fsl_gpio.o fsl_i2c.h fsl_i2c.o fsl_i2c_edma.h fsl_i2c_edma.o fsl_llwu.h fsl_llwu.o fsl_lptmr.h fsl_lptmr.o fsl_pdb.h fsl_pdb.o fsl_phy.h fsl_phy.o fsl_pit.h fsl_pit.o fsl_pmc.h fsl_pmc.o fsl_port.h fsl_rcm.h fsl_rcm.o fsl_rnga.h fsl_rnga.o fsl_rtc.h fsl_rtc.o fsl_sai.h fsl_sai.o fsl_sai_edma.h fsl_sai_edma.o fsl_sdhc.h fsl_sdhc.o fsl_sim.h fsl_sim.o fsl_smc.h fsl_smc.o fsl_sysmpu.h fsl_sysmpu.o fsl_uart.h fsl_uart.o fsl_uart_edma.h fsl_uart_edma.o fsl_vref.h fsl_vref.o fsl_wdog.h fsl_wdog.o gpio_api.o gpio_irq_api.o gpio_object.h i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_cmsis_conf.h mbed_crc_api.o mbed_overrides.o mbed_retarget.o mbed_rtx.h mbed_sdk_boot.o mbed_tz_context.o MK64F12.h MK64F12_features.h mpu_armv7.h mpu_armv8.h objects.h peripheral_clock_defines.h PeripheralNames.h PeripheralPins.h PeripheralPins.o pinmap.o PinNames.h port_api.o PortNames.h pwmout_api.o qspi_api.o rtc_api.o RTE_Components.h serial_api.o sleep.o spi_api.o startup_MK64F12.o storage_driver.o system_MK64F12.h system_MK64F12.o trng_api.o tz_context.h us_ticker.o
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_critical.h mbed_debug.h mbed_error.h mbed_error_hist.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h semihost_api.h SharedPtr.h SingletonPtr.h sleep.h Span.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/: mbed.h
    ./mbed/: Servo.cpp
  group servo_operation
    ./: main.cpp mbed_config.h
    ./: Stepper.h
